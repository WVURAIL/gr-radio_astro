options:
  parameters:
    author: Glen Langston
    description: Astronomy with 8.0 MHz SDRPlay RSP 1A
    generate_options: bokeh_gui
    id: nsf_integrate_80_web
    output_language: python
    title: 'Web display NsfIntegrate: SDRPlay 8MHz Astronomical Obs.'
  states: {}

blocks:
- name: Azimuth
  id: variable_bokehgui_textbox
  parameters:
    label: Azimuth
    type: real
    value: float( Azimuth_save)
  states: {}
- name: Azimuth_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: azimuth
    section: main
    type: real
    value: '90.'
    writeback: Azimuth
  states: {}
- name: Bandwidth
  id: variable_bokehgui_textbox
  parameters:
    label: Bandwidth
    type: int
    value: int(Bandwidths)
  states: {}
- name: Bandwidths
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: bandwidth
    section: main
    type: real
    value: 8.e6
    writeback: Bandwidth
  states: {}
- name: BiasOn
  id: variable
  parameters:
    value: bool(BiasOn_save)
  states: {}
- name: BiasOn_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: biason
    section: main
    type: bool
    value: 'False'
    writeback: BiasOn
  states: {}
- name: BroadcastNotch
  id: variable
  parameters:
    value: bool(BroadcastNotch_save)
  states: {}
- name: BroadcastNotch_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: broadcastnotch
    section: main
    type: bool
    value: 'False'
    writeback: BroadcastNotch
  states: {}
- name: ConfigFile
  id: variable
  parameters:
    value: ObsName+".conf"
  states: {}
- name: DabNotch
  id: variable
  parameters:
    value: bool(DabNotch_save)
  states: {}
- name: DabNotch_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: dabnotch
    section: main
    type: bool
    value: 'False'
    writeback: DabNotch
  states: {}
- name: DcOffsetMode
  id: variable
  parameters:
    value: bool(DcOffset_save)
  states: {}
- name: DcOffset_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: dcoffsetmode
    section: main
    type: bool
    value: 'False'
    writeback: DcOffsetMode
  states: {}
- name: DebugOn
  id: variable
  parameters:
    value: bool(DebugOn_save)
  states: {}
- name: DebugOn_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: debugon
    section: main
    type: bool
    value: 'False'
    writeback: DebugOn
  states: {}
- name: Device
  id: variable
  parameters:
    value: device_save
  states: {}
- name: Elevation
  id: variable_bokehgui_textbox
  parameters:
    label: Elevation
    type: real
    value: float(Elevation_save)
  states: {}
- name: Elevation_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: elevation
    section: main
    type: real
    value: '90.'
    writeback: Elevation
  states: {}
- name: Frequency
  id: variable_bokehgui_textbox
  parameters:
    label: Frequency
    type: real
    value: float(Frequencys)
  states: {}
- name: Frequencys
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Frequency
    section: main
    type: real
    value: 1420.4e6
    writeback: Frequency
  states: {}
- name: Gain1
  id: variable
  parameters:
    value: Gain1s
  states: {}
- name: Gain1s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain1
    section: main
    type: real
    value: '49.'
    writeback: Gain1
  states: {}
- name: Gain2
  id: variable
  parameters:
    value: IF_attn
  states: {}
- name: Gain3
  id: variable
  parameters:
    value: IF_attn
  states: {}
- name: H1
  id: variable
  parameters:
    value: 1420.406E6
  states: {}
- name: IF_attn
  id: variable
  parameters:
    value: float(IF_attn_save)
  states: {}
- name: IF_attn_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: ifattn
    section: main
    type: real
    value: '30'
    writeback: IF_attn
  states: {}
- name: IQMode
  id: variable
  parameters:
    value: bool(IQMode_save)
  states: {}
- name: IQMode_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: iqmode
    section: main
    type: bool
    value: 'False'
    writeback: IQMode
  states: {}
- name: ObsName
  id: variable
  parameters:
    value: '"Integrate80"'
  states: {}
- name: Record
  id: variable_bokehgui_radiobutton
  parameters:
    inline: 'True'
    label0: Wait
    label1: Average
    label2: Save
    label3: ''
    label4: ''
    labels: '[]'
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    options: '[0, 1, 2]'
    type: int
    value: '1'
  states: {}
- name: Telescope
  id: variable
  parameters:
    value: telescope_save
  states: {}
- name: Xaxis
  id: variable
  parameters:
    value: '0'
  states: {}
- name: device_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: device
    section: main
    type: string
    value: airspy,bias=1,pack=1
    writeback: Device
  states: {}
- name: fftsize
  id: variable
  parameters:
    value: fftsize_save
  states: {}
- name: fftsize_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: fftsize
    section: main
    type: int
    value: '1024'
    writeback: fftsize
  states: {}
- name: nAve
  id: variable
  parameters:
    value: int(nAves)
  states: {}
- name: nAves
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: nave
    section: main
    type: int
    value: '20'
    writeback: nAve
  states: {}
- name: numin
  id: variable
  parameters:
    value: (Frequency - (Bandwidth/2.))
  states: {}
- name: observer
  id: variable
  parameters:
    value: observers_save
  states: {}
- name: observers_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: observers
    section: main
    type: string
    value: Science Aficionado
    writeback: observer
  states: {}
- name: obstype
  id: variable_bokehgui_radiobutton
  parameters:
    inline: 'True'
    label0: Survey
    label1: Cold
    label2: Hot
    label3: Ref
    label4: ''
    labels: '[]'
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    options: '[0, 1, 2]'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Bandwidth
  states: {}
- name: telescope_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: telescope
    section: main
    type: string
    value: Bubble Wrap Horn
    writeback: Telescope
  states: {}
- name: units
  id: variable
  parameters:
    value: '0'
  states: {}
- name: xaxis_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Xaxis
    section: main
    type: int
    value: '0'
    writeback: Xaxis
  states: {}
- name: xmins
  id: variable
  parameters:
    value: '[numin*1E-6, (H1 - numin)*(3E5/H1), 0 , 0]'
  states: {}
- name: xsteps
  id: variable
  parameters:
    value: '[Bandwidth*1.E-6/fftsize, -Bandwidth*3.E5/(H1*fftsize), 1]'
  states: {}
- name: xunits
  id: variable
  parameters:
    value: '[ "MHz", "km.sec", "Channel"]'
  states: {}
- name: ymaxs
  id: variable
  parameters:
    value: '[5., 10., 180., 80.]'
  states: {}
- name: ymins
  id: variable
  parameters:
    value: '[ 0.01,  -20,  90.,-5.] '
  states: {}
- name: yunits
  id: variable
  parameters:
    value: '["Counts", "Power (dB)", "Intensity (Kelvins)", "Intensity (K)"]'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: bokehgui_vector_sink_x_0
  id: bokehgui_vector_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    alpha3: '1.0'
    alpha4: '1.0'
    alpha5: '1.0'
    alpha6: '1.0'
    alpha7: '1.0'
    alpha8: '1.0'
    average: '1.0'
    axislabels: 'True'
    color1: '"yellow"'
    color2: '"green"'
    color3: '"red"'
    color4: '"blue"'
    color5: '"cyan"'
    color6: '"magenta"'
    color7: '"yellow"'
    color8: '"dark red"'
    grid: 'False'
    label1: Latest
    label2: Ave
    label3: Hot
    label4: Cold
    label5: ''
    label6: ''
    label7: ''
    label8: ''
    legend: 'True'
    marker1: None
    marker2: None
    marker3: None
    marker4: None
    marker5: None
    marker6: None
    marker7: None
    marker8: None
    maxhold: 'False'
    name: '""'
    nconnections: '4'
    placement: (1,0,1,2)
    style1: '"solid"'
    style2: '"solid"'
    style3: '"solid"'
    style4: '"solid"'
    style5: '"solid"'
    style6: '"solid"'
    style7: '"solid"'
    style8: '"solid"'
    type: float
    update_time: '2000'
    vec_len: fftsize
    width1: '2'
    width2: '1'
    width3: '1'
    width4: '1'
    width5: '1'
    width6: '1'
    width7: '1'
    width8: '1'
    x_values: '[0,1]'
    xlabel: Channel
    xunit: (Int)
    ylabel: Intensity
    ymax: '4.'
    ymin: '-0.1'
    yunit: Counts
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.hamming(fftsize)
  states: {}
- name: note_1
  id: note
  parameters:
    note: The sequence of vector medians removes temporary RFI
  states: {}
- name: radio_astro_ra_ascii_sink_0
  id: radio_astro_ra_ascii_sink
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidths
    device: device_save
    elevation: Elevation
    frequency: Frequencys
    gain1: Gain1
    gain2: float(Gain2)
    gain3: float(Gain2)
    nave: nAve
    nmedian: 4**5
    observers: observer
    obstype: obstype
    record: Record
    setup: ObsName+".not"
    site: telescope_save
    vlen: fftsize
  states: {}
- name: radio_astro_ra_integrate_1
  id: radio_astro_ra_integrate
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidths
    elevation: Elevation
    frequency: Frequencys
    inttype: Record
    nmedian: 4**5
    observers: observers_save
    obstype: obstype
    setup: ObsName+".not"
    tcold: '10.'
    thot: '295.'
    units: units
    vlen: fftsize
  states: {}
- name: radio_astro_vmedian_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_1
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_2
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_2_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_3
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_3_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_3_1
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_3_2
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: sdrplay3_rsp1a_0
  id: sdrplay3_rsp1a
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    bandwidth: 8000e3
    biasT: bool(BiasOn)
    center_freq: Frequency
    dab_notch_filter: bool(DabNotch)
    dc_offset_mode: bool(DcOffsetMode)
    debug_mode: bool(DebugOn)
    freq_corr: '0'
    if_gRdB: Gain2
    iq_balance_mode: bool(IQMode)
    output_type: fc32
    rf_gRdB: Gain1
    rf_notch_filter: bool(BroadcastNotch)
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'True'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', radio_astro_vmedian_0_2, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [radio_astro_ra_ascii_sink_0, '0', blocks_null_sink_0, '0']
- [radio_astro_ra_integrate_1, '0', radio_astro_vmedian_0_3, '0']
- [radio_astro_ra_integrate_1, '1', radio_astro_vmedian_0_3_0, '0']
- [radio_astro_ra_integrate_1, '2', radio_astro_vmedian_0_3_1, '0']
- [radio_astro_ra_integrate_1, '3', radio_astro_vmedian_0_3_2, '0']
- [radio_astro_ra_integrate_1, '4', blocks_null_sink_0_0, '0']
- [radio_astro_vmedian_0, '0', radio_astro_vmedian_0_1, '0']
- [radio_astro_vmedian_0_0, '0', radio_astro_vmedian_0, '0']
- [radio_astro_vmedian_0_1, '0', radio_astro_ra_ascii_sink_0, '0']
- [radio_astro_vmedian_0_1, '0', radio_astro_ra_integrate_1, '0']
- [radio_astro_vmedian_0_2, '0', radio_astro_vmedian_0_2_0, '0']
- [radio_astro_vmedian_0_2_0, '0', radio_astro_vmedian_0_0, '0']
- [radio_astro_vmedian_0_3, '0', bokehgui_vector_sink_x_0, '0']
- [radio_astro_vmedian_0_3_0, '0', bokehgui_vector_sink_x_0, '1']
- [radio_astro_vmedian_0_3_1, '0', bokehgui_vector_sink_x_0, '2']
- [radio_astro_vmedian_0_3_2, '0', bokehgui_vector_sink_x_0, '3']
- [sdrplay3_rsp1a_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
