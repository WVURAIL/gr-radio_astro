options:
  parameters:
    author: Glen Langston
    description: AIRSPY Mini at full speed 6 MHz samples
    generate_options: qt_gui
    id: nsf_watch_60
    output_language: python
    qt_qss_theme: nsf.qss
    title: NSF Watch for Events whille recording spectra
  states: {}

blocks:
- name: Azimuth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,4,1,2
    label: Azimuth
    type: real
    value: Azimuth_save
  states: {}
- name: Azimuth_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: azimuth
    section: main
    type: real
    value: '90.'
    writeback: Azimuth
  states: {}
- name: Bandwidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,2,1,2
    label: Bandwidth
    type: real
    value: Bandwidths
  states: {}
- name: Bandwidths
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Bandwidth
    section: main
    type: real
    value: 6.e6
    writeback: Bandwidth
  states: {}
- name: ConfigFile
  id: variable
  parameters:
    value: ObsName+".conf"
  states: {}
- name: Device
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,1
    label: Dev
    type: string
    value: device_save
  states: {}
- name: Elevation
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,4,1,2
    label: Elevation
    type: real
    value: Elevation_save
  states: {}
- name: Elevation_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: elevation
    section: main
    type: real
    value: '90.'
    writeback: Elevation
  states: {}
- name: EventMode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4 ,1, 1, 1
    label: Event Mode
    label0: '! ! Wait ! !'
    label1: Write
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: Frequency
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,2
    label: Freq. Hz
    type: real
    value: Frequencys
  states: {}
- name: Frequencys
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Frequency
    section: main
    type: real
    value: 1420.4e6
    writeback: Frequency
  states: {}
- name: Gain1
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: Gain1
    labels: '[]'
    num_opts: '0'
    options: '[22,21,20,19,18,17,16,15,14,13,12,11,0]'
    type: real
    value: Gain1s
  states: {}
- name: Gain1s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain1
    section: main
    type: real
    value: '14'
    writeback: Gain1
  states: {}
- name: Gain2
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,3,1,1
    label: Gain2
    labels: '[]'
    num_opts: '0'
    options: '[22,21,20,19,18,17,16,15,14,13,12,11,0]'
    type: real
    value: Gain2s
  states: {}
- name: Gain2s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain2
    section: main
    type: real
    value: '12'
    writeback: Gain2
  states: {}
- name: Gain3
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,4,1,2
    label: Gain3
    labels: '[]'
    num_opts: '0'
    options: '[22,21,20,19,18,17,16,15,14,13,12,11,0]'
    type: real
    value: Gain3s
  states: {}
- name: Gain3s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain3
    section: main
    type: real
    value: '13.'
    writeback: Gain3
  states: {}
- name: ObsName
  id: variable
  parameters:
    value: '"Integrate60"'
  states: {}
- name: Record
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,1,1,1
    label: Spec. Mode
    label0: '! ! Wait ! !'
    label1: AVERAGE
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: Telescope
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: Tel
    type: string
    value: telescope_save
  states: {}
- name: device_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: device
    section: main
    type: string
    value: airspy,bias=1,pack=1
    writeback: Device
  states: {}
- name: fftsize
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,1
    label: FFT Size
    labels: '[]'
    num_opts: '0'
    options: '[4096, 2048, 1024, 512, 256, 128]'
    type: int
    value: fftsize_save
  states: {}
- name: fftsize_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: fftsize
    section: main
    type: int
    value: '2048'
    writeback: fftsize
  states: {}
- name: nAve
  id: variable
  parameters:
    value: int( tAve*Bandwidth/(fftsize*(4**4))) + 1
  states: {}
- name: nAves
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: nave
    section: main
    type: int
    value: '20'
    writeback: nAve
  states: {}
- name: nsigma
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,3,1,1
    label: N Sigma
    min_len: '100'
    start: '0.'
    step: '.1'
    stop: '10.'
    value: nsigmas
    widget: counter
  states: {}
- name: nsigmas
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: nsigma
    section: main
    type: real
    value: '5.5'
    writeback: nsigma
  states: {}
- name: observer
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Who
    type: string
    value: observers_save
  states: {}
- name: observers_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: observers
    section: main
    type: string
    value: Science Aficionado
    writeback: observer
  states: {}
- name: tAve
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: T Ave (s)
    type: real
    value: int( nAves * fftsize * 256 / Bandwidth)
  states: {}
- name: telescope_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: telescope
    section: main
    type: string
    value: Bubble Wrap Horn
    writeback: Telescope
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.hamming(fftsize)
  states: {}
- name: note_1
  id: note
  parameters:
    note: The sequence of vector medians removes temporary RFI
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: Device
    bb_gain0: float(Gain3)
    bw0: Bandwidth
    dc_offset_mode0: '2'
    freq0: Frequency
    gain0: float(Gain1)
    gain_mode0: 'False'
    if_gain0: float(Gain2)
    iq_balance_mode0: '2'
    sample_rate: Bandwidth
    sync: sync
    type: fc32
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: 4,0,1,1
    label1: I
    label2: Q
    nconnections: '2'
    size: fftsize
    type: float
    update_time: '1.'
    xmax: '.4'
    xmin: '-.4'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 4,3,1,1
    label1: 'T Remains:'
    max: nAve * fftsize * 1024. / Bandwidth
    min: '0.'
    type: float
    unit1: (s)
    update_time: '1.'
  states: {}
- name: radio_astro_detect_0
  id: radio_astro_detect
  parameters:
    bw: Bandwidth
    dms: nsigma
    f_obs: Frequency
    mode: '2'
    t_int: fftsize/Bandwidth
    vec_length: fftsize
  states: {}
- name: radio_astro_ra_ascii_sink_0
  id: radio_astro_ra_ascii_sink
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidth
    device: device_save
    elevation: Elevation
    frequency: Frequency
    gain1: float(Gain1)
    gain2: float(Gain2)
    gain3: float(Gain3)
    nave: nAve
    nmedian: 4**4
    observers: observer
    obstype: '0'
    record: Record
    setup: ObsName+".not"
    site: telescope_save
    vlen: fftsize
  states: {}
- name: radio_astro_ra_event_log_0
  id: radio_astro_ra_event_log
  parameters:
    bandwidth: Bandwidth
    logname: ''
    note: Event Detection
    vlen: fftsize
  states: {}
- name: radio_astro_ra_event_sink_0
  id: radio_astro_ra_event_sink
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidth
    device: Device
    elevation: Elevation
    frequency: Frequency
    gain1: float(Gain1)
    note: Event Detection
    observer: Observer
    record: EventMode
    setup: ObsName+"Event.not"
    telescope: Telescope
    vlen: fftsize
  states: {}
- name: radio_astro_vmedian_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0_1
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0_1_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_histogram_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', radio_astro_vmedian_0_0_1, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', radio_astro_detect_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_float_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [radio_astro_detect_0, '0', radio_astro_ra_event_log_0, '0']
- [radio_astro_detect_0, '0', radio_astro_ra_event_sink_0, '0']
- [radio_astro_ra_ascii_sink_0, '0', qtgui_number_sink_0, '0']
- [radio_astro_vmedian_0, '0', radio_astro_ra_ascii_sink_0, '0']
- [radio_astro_vmedian_0_0_0, '0', radio_astro_vmedian_0, '0']
- [radio_astro_vmedian_0_0_1, '0', radio_astro_vmedian_0_0_1_0, '0']
- [radio_astro_vmedian_0_0_1_0, '0', radio_astro_vmedian_0_0_0, '0']

metadata:
  file_format: 1
