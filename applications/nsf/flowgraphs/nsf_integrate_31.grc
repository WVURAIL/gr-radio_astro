options:
  parameters:
    author: Glen Langston
    description: PlutoSDR Dongle at maximum rate without dropping samples
    generate_options: qt_gui
    id: nsf_integrate_31
    output_language: python
    title: 'NsfIntegrate: Average+Record Obs.'
  states: {}

blocks:
- name: Azimuth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,6,1,1
    label: Azimuth
    type: real
    value: Azimuth_save
  states: {}
- name: Azimuth_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: azimuth
    section: main
    type: real
    value: '90.'
    writeback: Azimuth
  states: {}
- name: Bandwidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,4,1,2
    label: Bandwidth
    type: real
    value: Bandwidths
  states: {}
- name: Bandwidths
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Bandwidth
    section: main
    type: real
    value: 6.e6
    writeback: Bandwidth
  states: {}
- name: ConfigFile
  id: variable
  parameters:
    value: ObsName+".conf"
  states: {}
- name: Device
  id: variable
  parameters:
    value: '"ip:pluto.local"'
  states: {}
- name: Elevation
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,6,1,1
    label: Elevation
    type: real
    value: Elevation_save
  states: {}
- name: Elevation_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: elevation
    section: main
    type: real
    value: '90.'
    writeback: Elevation
  states: {}
- name: Frequency
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,4,1,2
    label: Freq. Hz
    type: real
    value: Frequencys
  states: {}
- name: Frequencys
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Frequency
    section: main
    type: real
    value: 1420.4e6
    writeback: Frequency
  states: {}
- name: Gain1
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,2
    label: Gain1
    type: real
    value: Gain1s
  states: {}
- name: Gain1s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain1
    section: main
    type: real
    value: '49.'
    writeback: Gain1
  states: {}
- name: Gain2
  id: variable
  parameters:
    value: '12.'
  states: {}
- name: H1
  id: variable
  parameters:
    value: 1420.406E6
  states: {}
- name: ObsName
  id: variable
  parameters:
    value: '"Integrate31"'
  states: {}
- name: Record
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,0,1,2
    label: 'Rec:'
    label0: '! ! Wait ! !'
    label1: AVERAGE
    label2: Save
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: Telescope
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,2
    label: Tel
    type: string
    value: telescope_save
  states: {}
- name: Xaxis
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6,3,1,3
    label: Xaxis
    label0: Frequency (MHz)
    label1: Velocity (km/sec)
    label2: Channels
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: xaxis_save
  states: {}
- name: device_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: device
    section: main
    type: string
    value: airspy,bias=1,pack=1
    writeback: Device
  states: {}
- name: fftsize
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,2,1,2
    label: FFT_size
    type: int
    value: fftsize_save
  states: {}
- name: fftsize_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: fftsize
    section: main
    type: int
    value: '1024'
    writeback: fftsize
  states: {}
- name: nAve
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,2
    label: N_Ave.
    type: int
    value: nAves
  states: {}
- name: nAves
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: nave
    section: main
    type: int
    value: '20'
    writeback: nAve
  states: {}
- name: numin
  id: variable
  parameters:
    value: (Frequency - (Bandwidth/2.))
  states: {}
- name: observer
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,2
    label: Who
    type: string
    value: observers_save
  states: {}
- name: observers_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: observers
    section: main
    type: string
    value: Science Aficionado
    writeback: observer
  states: {}
- name: obstype
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,0,1,2
    label: 'Obs:'
    label0: Survey
    label1: Hot/Cold
    label2: Ref
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(Bandwidth)
  states: {}
- name: telescope_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: telescope
    section: main
    type: string
    value: Bubble Wrap Horn
    writeback: Telescope
  states: {}
- name: units
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6,0,1,2
    label: Units
    label0: Counts
    label1: dB
    label2: Kelvins
    label3: K - Fit
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: xaxis_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Xaxis
    section: main
    type: int
    value: '0'
    writeback: Xaxis
  states: {}
- name: xaxis_save_0
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Xaxis
    section: main
    type: int
    value: '0'
    writeback: Xaxis
  states: {}
- name: xmins
  id: variable
  parameters:
    value: '[numin*1E-6, (H1 - numin)*(3E5/H1), 0 ]'
  states: {}
- name: xsteps
  id: variable
  parameters:
    value: '[Bandwidth*1.E-6/fftsize, -Bandwidth*3.E5/(H1*fftsize), 1]'
  states: {}
- name: ymaxs
  id: variable
  parameters:
    value: '[5, 10., 200., 50.]'
  states: {}
- name: ymins
  id: variable
  parameters:
    value: '[ 0.01,  -20,  90.,-.5] '
  states: {}
- name: yunits
  id: variable
  parameters:
    value: '["Counts", "Power (dB)", "Intensity (Kelvins)", "Intensity(K)"]'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.hamming(fftsize)
  states: {}
- name: note_1
  id: note
  parameters:
    note: The sequence of vector medians removes temporary RFI
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: 3,0,1,2
    label1: I
    label2: Q
    nconnections: '2'
    size: fftsize
    type: float
    update_time: '2'
    xmax: '.5'
    xmin: '-.5'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 6,6,1,1
    label1: 'T Remains:'
    max: nAve * fftsize * 1024. / Bandwidth
    min: '0.'
    type: float
    unit1: (s)
    update_time: '1.'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '2.'
    color1: '"yellow"'
    color2: '"dark green"'
    color3: '"red"'
    color4: '"blue"'
    gui_hint: 2,2,4,5
    label1: Latest
    label2: Median
    label3: Hot
    label4: Cold
    label5: Ref
    nconnections: '5'
    ref_level: 0.5*(ymins[units] + ymaxs[units])
    update_time: '1'
    vlen: fftsize
    width2: '3'
    width3: '2'
    width4: '2'
    width5: '3'
    x_axis_label: '""'
    x_start: xmins[Xaxis]
    x_step: xsteps[Xaxis]
    y_axis_label: Intensity
    ymax: ymaxs[units]
    ymin: ymins[units]
  states: {}
- name: radio_astro_ra_ascii_sink_0
  id: radio_astro_ra_ascii_sink
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidths
    device: device_save
    elevation: Elevation
    frequency: Frequencys
    gain1: float(Gain1)
    gain2: float(Gain2)
    gain3: float(Gain2)
    nave: nAve
    nmedian: 4**4
    observers: observer
    obstype: obstype
    record: Record
    setup: ObsName+".not"
    site: telescope_save
    vlen: fftsize
  states: {}
- name: radio_astro_ra_integrate_1
  id: radio_astro_ra_integrate
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidths
    elevation: Elevation
    frequency: Frequencys
    inttype: Record
    nmedian: 4**4
    observers: observers_save
    obstype: obstype
    setup: ObsName+".not"
    tcold: '10.'
    thot: '295.'
    units: units
    vlen: fftsize
  states: {}
- name: radio_astro_ra_vmedian_0
  id: radio_astro_ra_vmedian
  parameters:
    decimate: '4'
    vlen: fftsize
  states: {}
- name: radio_astro_ra_vmedian_0_0
  id: radio_astro_ra_vmedian
  parameters:
    decimate: '4'
    vlen: fftsize
  states: {}
- name: radio_astro_ra_vmedian_0_1
  id: radio_astro_ra_vmedian
  parameters:
    decimate: '4'
    vlen: fftsize
  states: {}
- name: radio_astro_ra_vmedian_0_1_0
  id: radio_astro_ra_vmedian
  parameters:
    decimate: '4'
    vlen: fftsize
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: 5e6
    center_freq: Frequency
    dev_args: Device
    gain: Gain1
    samp_rate: Bandwidth
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_histogram_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', radio_astro_ra_vmedian_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [radio_astro_ra_ascii_sink_0, '0', qtgui_number_sink_0, '0']
- [radio_astro_ra_integrate_1, '0', qtgui_vector_sink_f_0_0, '0']
- [radio_astro_ra_integrate_1, '1', qtgui_vector_sink_f_0_0, '1']
- [radio_astro_ra_integrate_1, '2', qtgui_vector_sink_f_0_0, '2']
- [radio_astro_ra_integrate_1, '3', qtgui_vector_sink_f_0_0, '3']
- [radio_astro_ra_integrate_1, '4', qtgui_vector_sink_f_0_0, '4']
- [radio_astro_ra_vmedian_0, '0', radio_astro_ra_vmedian_0_0, '0']
- [radio_astro_ra_vmedian_0_0, '0', radio_astro_ra_vmedian_0_1, '0']
- [radio_astro_ra_vmedian_0_1, '0', radio_astro_ra_vmedian_0_1_0, '0']
- [radio_astro_ra_vmedian_0_1_0, '0', radio_astro_ra_ascii_sink_0, '0']
- [radio_astro_ra_vmedian_0_1_0, '0', radio_astro_ra_integrate_1, '0']
- [soapy_plutosdr_source_0, '0', blocks_complex_to_float_0, '0']
- [soapy_plutosdr_source_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
