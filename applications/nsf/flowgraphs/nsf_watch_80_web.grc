options:
  parameters:
    author: Glen Langston
    description: Astronomy with 8.0 MHz SDRPlay RSP 1A
    generate_options: bokeh_gui
    id: nsf_watch_80_web
    output_language: python
    title: 'Web display Nsf Detect: SDRPlay 8MHz Astronomical Obs.'
  states: {}

blocks:
- name: Azimuth
  id: variable_bokehgui_label
  parameters:
    label: Azimuth
    type: real
    value: float(Azimuth_save)
  states: {}
- name: Azimuth_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: azimuth
    section: main
    type: real
    value: '90.'
    writeback: Azimuth
  states: {}
- name: Bandwidth
  id: variable_bokehgui_label
  parameters:
    label: ''
    type: real
    value: float(Bandwidths)
  states: {}
- name: Bandwidths
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: bandwidth
    section: main
    type: real
    value: 8.e6
    writeback: Bandwidth
  states: {}
- name: BiasOn
  id: variable
  parameters:
    value: bool(BiasOn_save)
  states: {}
- name: BiasOn_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: biason
    section: main
    type: bool
    value: 'False'
    writeback: BiasOn
  states: {}
- name: BroadcastNotch
  id: variable
  parameters:
    value: bool(BroadcastNotch_save)
  states: {}
- name: BroadcastNotch_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: broadcastnotch
    section: main
    type: bool
    value: 'False'
    writeback: BroadcastNotch
  states: {}
- name: ConfigFile
  id: variable
  parameters:
    value: ObsName+".conf"
  states: {}
- name: DabNotch
  id: variable
  parameters:
    value: bool(DabNotch_save)
  states: {}
- name: DabNotch_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: dabnotch
    section: main
    type: bool
    value: 'False'
    writeback: DabNotch
  states: {}
- name: DcOffsetMode
  id: variable
  parameters:
    value: bool(DcOffset_save)
  states: {}
- name: DcOffset_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: dcoffsetmode
    section: main
    type: bool
    value: 'False'
    writeback: DcOffsetMode
  states: {}
- name: DebugOn
  id: variable
  parameters:
    value: bool(DebugOn_save)
  states: {}
- name: DebugOn_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: debugon
    section: main
    type: bool
    value: 'False'
    writeback: DebugOn
  states: {}
- name: Device
  id: variable
  parameters:
    value: device_save
  states: {}
- name: Elevation
  id: variable_bokehgui_label
  parameters:
    label: Elevation
    type: real
    value: float(Elevation_save)
  states: {}
- name: Elevation_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: elevation
    section: main
    type: real
    value: '90.'
    writeback: Elevation
  states: {}
- name: Explanation
  id: variable_bokehgui_label
  parameters:
    label: ''
    type: string
    value: NSF Watch Horn Radio Telescope with SDRPlay
  states: {}
- name: Frequency
  id: variable_bokehgui_label
  parameters:
    label: ''
    type: real
    value: float(Frequencys)
  states: {}
- name: Frequencys
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Frequency
    section: main
    type: real
    value: 1420.4e6
    writeback: Frequency
  states: {}
- name: Gain1
  id: variable
  parameters:
    value: Gain1s
  states: {}
- name: Gain1s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain1
    section: main
    type: real
    value: '49.'
    writeback: Gain1
  states: {}
- name: Gain2
  id: variable
  parameters:
    value: IF_attn
  states: {}
- name: Gain3
  id: variable
  parameters:
    value: IF_attn
  states: {}
- name: H1
  id: variable
  parameters:
    value: 1420.406E6
  states: {}
- name: IF_attn
  id: variable
  parameters:
    value: float(IF_attn_save)
  states: {}
- name: IF_attn_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: ifattn
    section: main
    type: real
    value: '30'
    writeback: IF_attn
  states: {}
- name: IQMode
  id: variable
  parameters:
    value: bool(IQMode_save)
  states: {}
- name: IQMode_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: iqmode
    section: main
    type: bool
    value: 'False'
    writeback: IQMode
  states: {}
- name: ObsName
  id: variable
  parameters:
    value: '"Integrate80"'
  states: {}
- name: Observer
  id: variable_bokehgui_label
  parameters:
    label: ''
    type: string
    value: observers_save
  states: {}
- name: Record
  id: variable_bokehgui_label
  parameters:
    label: Record
    type: int
    value: 'True'
  states: {}
- name: Samples
  id: variable_bokehgui_label
  parameters:
    label: N samples
    type: int
    value: int(fftsize_save)
  states: {}
- name: Telescope
  id: variable_bokehgui_label
  parameters:
    label: ''
    type: string
    value: telescope_save
  states: {}
- name: device_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: device
    section: main
    type: string
    value: airspy,bias=1,pack=1
    writeback: Device
  states: {}
- name: fftsize
  id: variable
  parameters:
    value: fftsize_save
  states: {}
- name: fftsize_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: fftsize
    section: main
    type: int
    value: '1024'
    writeback: fftsize
  states: {}
- name: nAve
  id: variable
  parameters:
    value: int(nAves)
  states: {}
- name: nAves
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: nave
    section: main
    type: int
    value: '20'
    writeback: nAve
  states: {}
- name: nsigma
  id: variable_bokehgui_label
  parameters:
    label: N Sigma
    type: real
    value: float(nsigmas)
  states: {}
- name: nsigmas
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: nsigma
    section: main
    type: real
    value: '5.5'
    writeback: nsigma
  states: {}
- name: observer
  id: variable
  parameters:
    value: observers_save
  states: {}
- name: observers_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: observers
    section: main
    type: string
    value: Science Aficionado
    writeback: observer
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Bandwidth
  states: {}
- name: telescope_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: telescope
    section: main
    type: string
    value: Bubble Wrap Horn
    writeback: Telescope
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: bokehgui_vector_sink_x_0
  id: bokehgui_vector_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    average: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    grid: 'False'
    label1: I
    label2: Q
    legend: 'True'
    marker1: None
    marker2: '''sx'''
    maxhold: 'False'
    name: '""'
    nconnections: '1'
    placement: (0,1,1,1)
    style1: '"solid"'
    style2: '"solid"'
    type: complex
    update_time: '1000'
    vec_len: fftsize
    width1: '1'
    width2: '1'
    x_values: (0,1)
    xlabel: Time
    xunit: '"Microseconds"'
    ylabel: Inensity
    ymax: '.9'
    ymin: '-.9'
    yunit: Counts
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.hamming(fftsize)
  states: {}
- name: note_1
  id: note
  parameters:
    note: The sequence of vector medians removes temporary RFI
  states: {}
- name: radio_astro_detect_0
  id: radio_astro_detect
  parameters:
    bw: Bandwidth
    dms: nsigma
    f_obs: Frequency
    mode: 'True'
    t_int: fftsize/Bandwidth
    vec_length: fftsize
  states: {}
- name: radio_astro_ra_ascii_sink_0
  id: radio_astro_ra_ascii_sink
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidth
    device: device_save
    elevation: Elevation
    frequency: Frequency
    gain1: float(IF_attn)
    gain2: float(Gain2)
    gain3: float(Gain1)
    nave: nAve
    nmedian: 4**5
    observers: observer
    obstype: '0'
    record: Record
    setup: ObsName+".not"
    site: telescope_save
    vlen: fftsize
  states: {}
- name: radio_astro_ra_event_sink_0
  id: radio_astro_ra_event_sink
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidth
    device: Device
    elevation: Elevation
    frequency: Frequency
    gain1: float(IF_attn)
    note: Event Detection
    observer: Observer
    record: 'True'
    setup: ObsName+"Event.not"
    telescope: Telescope
    vlen: fftsize
  states: {}
- name: radio_astro_vmedian_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0_1
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0_1_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: sdrplay3_rsp1a_0
  id: sdrplay3_rsp1a
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    bandwidth: 8000e3
    biasT: bool(BiasOn)
    center_freq: Frequency
    dab_notch_filter: bool(DabNotch)
    dc_offset_mode: bool(DcOffsetMode)
    debug_mode: bool(DebugOn)
    freq_corr: '0'
    if_gRdB: Gain2
    iq_balance_mode: bool(IQMode)
    output_type: fc32
    rf_gRdB: Gain1
    rf_notch_filter: bool(BroadcastNotch)
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'True'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: DataVector
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: DataVector
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', radio_astro_vmedian_0_0_1, '0']
- [blocks_stream_to_vector_0_0, '0', radio_astro_detect_0, '0']
- [blocks_stream_to_vector_0_0, '0', virtual_sink_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [radio_astro_detect_0, '0', bokehgui_vector_sink_x_0, '0']
- [radio_astro_detect_0, '0', radio_astro_ra_event_sink_0, '0']
- [radio_astro_ra_ascii_sink_0, '0', blocks_null_sink_0, '0']
- [radio_astro_vmedian_0, '0', radio_astro_ra_ascii_sink_0, '0']
- [radio_astro_vmedian_0_0, '0', radio_astro_vmedian_0, '0']
- [radio_astro_vmedian_0_0_0, '0', radio_astro_vmedian_0_0, '0']
- [radio_astro_vmedian_0_0_1, '0', radio_astro_vmedian_0_0_1_0, '0']
- [radio_astro_vmedian_0_0_1_0, '0', radio_astro_vmedian_0_0_0, '0']
- [sdrplay3_rsp1a_0, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_0, '0', fft_vxx_0_0, '0']

metadata:
  file_format: 1
