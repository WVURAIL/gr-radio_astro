<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Channel_width</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>centre_frequency</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>custom_window</value></param>
<param><key>value</key><value>sinc*np.hamming(4*vec_length)
</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>radio_signal</value></param>
<param><key>value</key><value>100.1e6</value></param>
<param><key>label</key><value>Radio signal</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>80e6</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>120e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sinc</value></param>
<param><key>value</key><value>np.sinc(sinc_sample_locations/np.pi)
</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sinc_sample_locations</value></param>
<param><key>value</key><value>np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/vec_length)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec_length</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1</value></param>
<param><key>delay</key><value>1024*2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_3</value></param>
<param><key>delay</key><value>1024*3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>custom_window[-vec_length:]
</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>custom_window[2*vec_length:3*vec_length]
</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_3</value></param>
<param><key>const</key><value>custom_window[0:vec_length]
</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4</value></param>
<param><key>const</key><value>custom_window[vec_length:2*vec_length]
</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>radio_astro_hdf5_sink</key>
<param><key>id</key><value>radio_astro_hdf5_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fname</key><value>grec</value></param>
<param><key>freq_start</key><value>1000000000</value></param>
<param><key>freq_step</key><value>10000000</value></param>
<param><key>n_inputs</key><value>1</value></param>
<param><key>notes</key><value></value></param>
<param><key>pointing</key><value>n</value></param>
<param><key>vec_length</key><value>1</value></param>
</block>
<block>
<key>radio_astro_hdf5_sink</key>
<param><key>id</key><value>radio_astro_hdf5_sink_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fname</key><value>greccc</value></param>
<param><key>freq_start</key><value>1000000000</value></param>
<param><key>freq_step</key><value>10000000</value></param>
<param><key>n_inputs</key><value>1</value></param>
<param><key>notes</key><value></value></param>
<param><key>pointing</key><value>n</value></param>
<param><key>vec_length</key><value>1024</value></param>
</block>
<block>
<key>radio_astro_hdf5_sink</key>
<param><key>id</key><value>radio_astro_hdf5_sink_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fname</key><value>gre</value></param>
<param><key>freq_start</key><value>1000000000</value></param>
<param><key>freq_step</key><value>10000000</value></param>
<param><key>n_inputs</key><value>1</value></param>
<param><key>notes</key><value></value></param>
<param><key>pointing</key><value>n</value></param>
<param><key>vec_length</key><value>1</value></param>
</block>
<block>
<key>radio_astro_hdf5_sink</key>
<param><key>id</key><value>radio_astro_hdf5_sink_0_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fname</key><value>grecccc</value></param>
<param><key>freq_start</key><value>1000000000</value></param>
<param><key>freq_step</key><value>10000000</value></param>
<param><key>n_inputs</key><value>1</value></param>
<param><key>notes</key><value></value></param>
<param><key>pointing</key><value>n</value></param>
<param><key>vec_length</key><value>1</value></param>
</block>
<block>
<key>radio_astro_hdf5_sink</key>
<param><key>id</key><value>radio_astro_hdf5_sink_0_1_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fname</key><value>greccccc</value></param>
<param><key>freq_start</key><value>1000000000</value></param>
<param><key>freq_step</key><value>10000000</value></param>
<param><key>n_inputs</key><value>1</value></param>
<param><key>notes</key><value></value></param>
<param><key>pointing</key><value>n</value></param>
<param><key>vec_length</key><value>1</value></param>
</block>
<block>
<key>radio_astro_hdf5_sink</key>
<param><key>id</key><value>radio_astro_hdf5_sink_0_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fname</key><value>grecc</value></param>
<param><key>freq_start</key><value>1000000000</value></param>
<param><key>freq_step</key><value>10000000</value></param>
<param><key>n_inputs</key><value>1</value></param>
<param><key>notes</key><value></value></param>
<param><key>pointing</key><value>n</value></param>
<param><key>vec_length</key><value>1024</value></param>
</block>
<block>
<key>spectrometer_basic_black</key>
<param><key>id</key><value>spectrometer_basic_black_0</value></param>
<param><key>centre_frequency</key><value>100000000</value></param>
<param><key>Channel_width</key><value>200000</value></param>
<param><key>samp_rate</key><value>2000000</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_delay_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>spectrometer_basic_black_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>radio_astro_hdf5_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>radio_astro_hdf5_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>radio_astro_hdf5_sink_0_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>radio_astro_hdf5_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_3</source_block_id><sink_block_id>blocks_stream_to_vector_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectrometer_basic_black_0</source_block_id><sink_block_id>blocks_complex_to_float_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectrometer_basic_black_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectrometer_basic_black_0</source_block_id><sink_block_id>radio_astro_hdf5_sink_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectrometer_basic_black_0</source_block_id><sink_block_id>radio_astro_hdf5_sink_0_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
