options:
  parameters:
    author: Franco Venturi (minor contibution from Glen Langston)
    copyright: Franco Venturi
    description: RSP1A test adding minimal guui to display power levels
    generate_options: qt_gui
    id: rsp1a_demo
    output_language: python
    title: Demo RSP1A
  states: {}

blocks:
- name: Frequency
  id: variable
  parameters:
    value: 1422e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: Frequency
    fftsize: '1024'
    gui_hint: 0,3,3,3
    type: complex
    update_time: '1'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '50'
    grid: 'True'
    gui_hint: 0,0,3,3
    label1: I
    label2: Q
    nconnections: '2'
    size: '1024'
    type: float
    update_time: '1'
    xmax: '0.5'
    xmin: '-0.5'
  states: {}
- name: sdrplay3_rsp1a_0
  id: sdrplay3_rsp1a
  parameters:
    AGC: 'False'
    agc_set_point: '-40'
    bandwidth: 7000e3
    biasT: 'False'
    center_freq: Frequency
    dab_notch_filter: 'True'
    dc_offset_mode: 'True'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: '28'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRdB: '3'
    rf_notch_filter: 'True'
    rsp_selector: '""'
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'True'
    show_gain_changes: 'True'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_histogram_sink_x_0, '1']
- [sdrplay3_rsp1a_0, '0', blocks_complex_to_float_0, '0']
- [sdrplay3_rsp1a_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
