<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>NsfWatch100NoGui</value></param>
<param><key>author</key><value>Glen Langston</value></param>
<param><key>description</key><value>AIRSPY Dongle at full speed 10 MHz samples</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>NSF Airspy 10 MHz - No Gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Azimuth</value></param>
<param><key>value</key><value>Azimuth_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Azimuth_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>90.</value></param>
<param><key>option</key><value>azimuth</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Azimuth</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bandwidth</value></param>
<param><key>value</key><value>Bandwidths</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Bandwidths</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>10.e6</value></param>
<param><key>option</key><value>Bandwidth</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Bandwidth</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ConfigFile</value></param>
<param><key>value</key><value>ObsName+".conf"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Device</value></param>
<param><key>value</key><value>device_save</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Elevation</value></param>
<param><key>value</key><value>Elevation_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Elevation_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>90.</value></param>
<param><key>option</key><value>elevation</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Elevation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EventMode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Frequency</value></param>
<param><key>value</key><value>Frequencys</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Frequencys</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>1420.4e6</value></param>
<param><key>option</key><value>Frequency</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Frequency</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain1</value></param>
<param><key>value</key><value>Gain1s</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Gain1s</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>14.</value></param>
<param><key>option</key><value>gain1</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Gain1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain2</value></param>
<param><key>value</key><value>Gain2s</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Gain2s</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>12</value></param>
<param><key>option</key><value>gain2</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Gain2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain3</value></param>
<param><key>value</key><value>Gain3s</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Gain3s</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>13</value></param>
<param><key>option</key><value>gain3</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Gain3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ObsName</value></param>
<param><key>value</key><value>"Integrate100"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Record</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Telescope</value></param>
<param><key>value</key><value>telescope_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>device_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>airspy,bias=1,pack=1</value></param>
<param><key>option</key><value>device</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>Device</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>fftsize_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>fftsize_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>option</key><value>fftsize</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>fftsize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nAve</value></param>
<param><key>value</key><value>nAves</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nAves</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>20</value></param>
<param><key>option</key><value>nave</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nAve</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nsigma</value></param>
<param><key>value</key><value>nsigmas</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nsigmas</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>5.5</value></param>
<param><key>option</key><value>nsigma</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>nsigma</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>observer</value></param>
<param><key>value</key><value>observers_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>observers_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>Science Aficionado</value></param>
<param><key>option</key><value>observers</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>observer</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>telescope_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>Bubble Wrap Horn</value></param>
<param><key>option</key><value>telescope</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>Telescope</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>2*fftsize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.hamming(fftsize)</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>The sequence of vector medians removes temporary RFI</value></param>
</block>
<block>
<key>radio_astro_detect</key>
<param><key>id</key><value>radio_astro_detect_0</value></param>
<param><key>mode</key><value>2</value></param>
<param><key>dms</key><value>nsigma</value></param>
<param><key>bw</key><value>Bandwidth</value></param>
<param><key>f_obs</key><value>Frequency</value></param>
<param><key>t_int</key><value>fftsize*1.e-6/Bandwidth</value></param>
<param><key>vec_length</key><value>2*fftsize</value></param>
</block>
<block>
<key>radio_astro_ra_ascii_sink</key>
<param><key>id</key><value>radio_astro_ra_ascii_sink_0</value></param>
<param><key>azimuth</key><value>Azimuth</value></param>
<param><key>bandwidth</key><value>Bandwidth</value></param>
<param><key>device</key><value>device_save</value></param>
<param><key>elevation</key><value>Elevation</value></param>
<param><key>frequency</key><value>Frequency</value></param>
<param><key>gain1</key><value>float(Gain1)</value></param>
<param><key>gain2</key><value>float(Gain2)</value></param>
<param><key>gain3</key><value>float(Gain3)</value></param>
<param><key>observers</key><value>observer</value></param>
<param><key>obstype</key><value>0</value></param>
<param><key>record</key><value>Record</value></param>
<param><key>setup</key><value>ObsName+".not"</value></param>
<param><key>site</key><value>telescope_save</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>nave</key><value>nAve</value></param>
<param><key>nmedian</key><value>4**5</value></param>
</block>
<block>
<key>radio_astro_ra_event_log</key>
<param><key>id</key><value>radio_astro_ra_event_log_0</value></param>
<param><key>logname</key><value></value></param>
<param><key>note</key><value>Event Detection</value></param>
<param><key>sample_rate</key><value>Bandwidth*1.e-6</value></param>
<param><key>vlen</key><value>2*fftsize</value></param>
</block>
<block>
<key>radio_astro_ra_event_sink</key>
<param><key>id</key><value>radio_astro_ra_event_sink_0</value></param>
<param><key>azimuth</key><value>Azimuth</value></param>
<param><key>sample_rate</key><value>Bandwidth*1.E-6</value></param>
<param><key>device</key><value>Device</value></param>
<param><key>elevation</key><value>Elevation</value></param>
<param><key>frequency</key><value>Frequency*1.E-6</value></param>
<param><key>gain1</key><value>float(Gain1)</value></param>
<param><key>note</key><value>Event Detection</value></param>
<param><key>observer</key><value>Observer</value></param>
<param><key>record</key><value>EventMode</value></param>
<param><key>setup</key><value>ObsName+"Event.not"</value></param>
<param><key>telescope</key><value>Telescope</value></param>
<param><key>vlen</key><value>2*fftsize</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_0_1</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_0_1_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>float(Gain2)</value></param>
<param><key>bw0</key><value>Bandwidth</value></param>
<param><key>freq0</key><value>Frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>float(Gain2)</value></param>
<param><key>gain0</key><value>float(Gain1)</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>args</key><value>Device</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>Bandwidth</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>radio_astro_vmedian_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>radio_astro_detect_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_detect_0</source_block_id><sink_block_id>radio_astro_ra_event_log_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_detect_0</source_block_id><sink_block_id>radio_astro_ra_event_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_ra_ascii_sink_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0</source_block_id><sink_block_id>radio_astro_ra_ascii_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_0</source_block_id><sink_block_id>radio_astro_vmedian_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_0_0</source_block_id><sink_block_id>radio_astro_vmedian_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_0_1</source_block_id><sink_block_id>radio_astro_vmedian_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_0_1_0</source_block_id><sink_block_id>radio_astro_vmedian_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
