options:
  parameters:
    author: Glen Langston
    description: This GRC demo compares the outputs of average and median with straght vector plotting
    generate_options: bokeh_gui
    id: vector_demo_bokeh
    max_nouts: '1'
    output_language: python
    title: Vector averaging and median comparison
  states: {}

blocks:
- name: fftsize
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: x10
  id: variable
  parameters:
    value: '[0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15]'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.1'
    freq: 3e5
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '.05'
    freq: 2e5
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '[50.]*fftsize'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '[0.]*fftsize'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '[100.]*fftsize'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '4'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '4'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
    vlen: fftsize
  states: {}
- name: bokehgui_vector_sink_x_0
  id: bokehgui_vector_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    alpha3: '1.0'
    alpha4: '1.0'
    alpha5: '1.0'
    alpha6: '1.0'
    average: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    color3: '"green"'
    color4: '"black"'
    color5: '"cyan"'
    color6: '"magenta"'
    grid: 'False'
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    label5: ''
    label6: ''
    legend: 'True'
    marker1: None
    marker2: None
    marker3: None
    marker4: None
    marker5: None
    marker6: None
    maxhold: 'False'
    name: '""'
    nconnections: '3'
    placement: '[0,0]'
    style1: '"solid"'
    style2: '"solid"'
    style3: '"solid"'
    style4: '"solid"'
    style5: '"solid"'
    style6: '"solid"'
    type: float
    update_time: '500'
    vec_len: fftsize
    width1: '1'
    width2: '1'
    width3: '1'
    width4: '1'
    width5: '1'
    width6: '1'
    x_values: '[1,fftsize]'
    xlabel: Samples
    xunit: '""'
    ylabel: Intensity
    ymax: '150'
    ymin: '-10'
    yunit: Counts
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: radio_astro_ra_vave_0
  id: radio_astro_ra_vave
  parameters:
    decimate: '4'
    vlen: fftsize
  states: {}
- name: radio_astro_ra_vave_0_0
  id: radio_astro_ra_vave
  parameters:
    decimate: '4'
    vlen: fftsize
  states: {}
- name: radio_astro_ra_vmedian_0
  id: radio_astro_ra_vmedian
  parameters:
    decimate: '4'
    vlen: fftsize
  states: {}
- name: radio_astro_ra_vmedian_0_0
  id: radio_astro_ra_vmedian
  parameters:
    decimate: '4'
    vlen: fftsize
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', bokehgui_vector_sink_x_0, '1']
- [blocks_add_const_vxx_0_0, '0', bokehgui_vector_sink_x_0, '2']
- [blocks_add_const_vxx_0_1, '0', bokehgui_vector_sink_x_0, '0']
- [blocks_add_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_throttle_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_throttle_0, '0', radio_astro_ra_vave_0, '0']
- [blocks_throttle_0, '0', radio_astro_ra_vmedian_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [radio_astro_ra_vave_0, '0', radio_astro_ra_vave_0_0, '0']
- [radio_astro_ra_vave_0_0, '0', blocks_add_const_vxx_0, '0']
- [radio_astro_ra_vmedian_0, '0', radio_astro_ra_vmedian_0_0, '0']
- [radio_astro_ra_vmedian_0_0, '0', blocks_add_const_vxx_0_0, '0']

metadata:
  file_format: 1
