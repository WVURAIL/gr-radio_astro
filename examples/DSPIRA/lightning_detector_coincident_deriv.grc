options:
  parameters:
    author: kbandura
    generate_options: qt_gui
    id: lightning_detector
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: const_chooser
  id: variable_qtgui_chooser
  parameters:
    label: 'choose '
    label0: '0'
    label1: '1'
    label2: '2'
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: derivative_amp
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1419e6
  states: {}
- name: integration_time
  id: variable
  parameters:
    value: '.2'
  states: {}
- name: min_integration
  id: variable
  parameters:
    comment: |-
      At least integrate 16 times, ~6milliseconds 
      Keep this for normailzation
    value: '16'
  states: {}
- name: reset_integration_button
  id: variable_qtgui_push_button
  parameters:
    label: Integration Reset
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: short_long_time_scale
  id: variable
  parameters:
    value: int(integration_time*samp_rate/vec_length/min_integration)
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    type: int
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_complex_to_real_1_0
  id: blocks_complex_to_real
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: vec_length*16*30
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: vec_length*16*30
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: vec_length
    type: float
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: vec_length
    type: float
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: min_integration
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: min_integration
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length*16
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length*16
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_length
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_length
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(vec_length)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(vec_length)
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 10e6
    analog_bandw_ch1: 10e6
    calibr_bandw_ch0: 10e6
    calibr_bandw_ch1: 10e6
    ch_align: 'False'
    channel_mode: '2'
    gain_dB_ch0: '45'
    gain_dB_ch1: '45'
    lna_path_ch0: '3'
    lna_path_ch1: '3'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_histogram_sink_x_0_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    size: 8*30
    srate: samp_rate/(vec_length*16)
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    size: 8*30
    srate: samp_rate/(vec_length*16)
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    size: 8*30
    srate: samp_rate/(vec_length*16)
    type: float
  states: {}
- name: radio_astro_comparator_0
  id: radio_astro_comparator
  parameters:
    level: derivative_amp
  states: {}
- name: radio_astro_comparator_0_0
  id: radio_astro_comparator
  parameters:
    level: derivative_amp
  states: {}
- name: radio_astro_triggered_save_csv_0
  id: radio_astro_triggered_save_csv
  parameters:
    notes: input1
    save_length: int(4000000/(vec_length*16))
    vec_length: vec_length*16
  states: {}
- name: radio_astro_triggered_save_csv_0_0
  id: radio_astro_triggered_save_csv
  parameters:
    notes: input2
    save_length: int(4000000/(vec_length*16))
    vec_length: vec_length*16
  states: {}
- name: radio_astro_vector_moving_average_0
  id: radio_astro_vector_moving_average
  parameters:
    averaging_length: short_long_time_scale
    intype: float
    reset_integration: reset_integration_button
    vec_length: vec_length
  states: {}
- name: radio_astro_vector_moving_average_0_0
  id: radio_astro_vector_moving_average
  parameters:
    averaging_length: short_long_time_scale
    intype: float
    reset_integration: reset_integration_button
    vec_length: vec_length
  states: {}

connections:
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_abs_xx_0, '0', radio_astro_comparator_0, '0']
- [blocks_abs_xx_0_0, '0', radio_astro_comparator_0_0, '0']
- [blocks_and_xx_0, '0', radio_astro_triggered_save_csv_0, '0']
- [blocks_and_xx_0, '0', radio_astro_triggered_save_csv_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_histogram_sink_x_0_0, '0']
- [blocks_complex_to_real_1, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_complex_to_real_1_0, '0', blocks_integrate_xx_0_0_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_delay_1, '0', blocks_sub_xx_0, '1']
- [blocks_delay_1_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_int_to_float_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_delay_1, '0']
- [blocks_integrate_xx_0, '0', blocks_sub_xx_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_delay_1_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_integrate_xx_0_0_0, '0', radio_astro_vector_moving_average_0, '0']
- [blocks_integrate_xx_0_0_0_0, '0', radio_astro_vector_moving_average_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_1, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_complex_to_real_1_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', radio_astro_triggered_save_csv_0, '1']
- [blocks_stream_to_vector_0_0_0, '0', radio_astro_triggered_save_csv_0_0, '1']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_abs_xx_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_abs_xx_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_integrate_xx_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_integrate_xx_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [limesdr_source_0, '0', blocks_complex_to_real_0, '0']
- [limesdr_source_0, '0', blocks_delay_0, '0']
- [limesdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [limesdr_source_0, '1', blocks_complex_to_real_0_0, '0']
- [limesdr_source_0, '1', blocks_delay_0_0, '0']
- [limesdr_source_0, '1', blocks_stream_to_vector_0_1, '0']
- [radio_astro_comparator_0, '0', blocks_and_xx_0, '1']
- [radio_astro_comparator_0, '0', blocks_int_to_float_0, '0']
- [radio_astro_comparator_0_0, '0', blocks_and_xx_0, '0']
- [radio_astro_comparator_0_0, '0', blocks_int_to_float_0_0, '0']
- [radio_astro_vector_moving_average_0, '0', blocks_vector_to_stream_0, '0']
- [radio_astro_vector_moving_average_0_0, '0', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
