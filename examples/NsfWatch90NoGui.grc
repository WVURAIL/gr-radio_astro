<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>NsfWatch90NoGui</value></param>
<param><key>author</key><value>Glen Langston</value></param>
<param><key>description</key><value>SDRPlay RSP1A, 9 MHz samples</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>NSF Watch 9MHz SDRPlay</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Azimuth</value></param>
<param><key>value</key><value>Azimuth_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Azimuth_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>90.</value></param>
<param><key>option</key><value>azimuth</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Azimuth</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bandwidth</value></param>
<param><key>value</key><value>Bandwidths</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Bandwidths</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>9.e6</value></param>
<param><key>option</key><value>Bandwidth</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Bandwidth</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BiasOn</value></param>
<param><key>value</key><value>BiasOn_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>BiasOn_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>biason</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>BiasOn</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BroadcastNotch</value></param>
<param><key>value</key><value>BroadcastNotch_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>BroadcastNotch_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>broadcastnotch</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>BroadcastNotch</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ConfigFile</value></param>
<param><key>value</key><value>ObsName+".conf"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DabNotch</value></param>
<param><key>value</key><value>DabNotch_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>DabNotch_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>dabnotch</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>DabNotch</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DcOffsetMode</value></param>
<param><key>value</key><value>DcOffsetMode_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>DcOffsetMode_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>dcoffsetmode</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>DcOffsetMode</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DebugOn</value></param>
<param><key>value</key><value>DebugOn_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>DebugOn_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>debugon</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>DebugOn</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Device</value></param>
<param><key>value</key><value>device_save</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Elevation</value></param>
<param><key>value</key><value>Elevation_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Elevation_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>90.</value></param>
<param><key>option</key><value>elevation</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Elevation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EventMode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Frequency</value></param>
<param><key>value</key><value>Frequencys</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Frequencys</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>1420.4e6</value></param>
<param><key>option</key><value>Frequency</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Frequency</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain1</value></param>
<param><key>value</key><value>Gain1s</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Gain1s</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>49.</value></param>
<param><key>option</key><value>gain1</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Gain1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain2</value></param>
<param><key>value</key><value>12.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain2_1</value></param>
<param><key>value</key><value>12.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>H1</value></param>
<param><key>value</key><value>1420.406E6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>IF_attn</value></param>
<param><key>value</key><value>IF_attn_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>IF_attn_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>30</value></param>
<param><key>option</key><value>ifattn</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>IF_attn</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>IQMode</value></param>
<param><key>value</key><value>IQMode_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>IQMode_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>iqmode</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>IQMode</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ObsName</value></param>
<param><key>value</key><value>"Integrate90"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Record</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Telescope</value></param>
<param><key>value</key><value>telescope_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>device_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>airspy,bias=1,pack=1</value></param>
<param><key>option</key><value>device</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>Device</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>fftsize_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>fftsize_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>option</key><value>fftsize</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>fftsize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nAve</value></param>
<param><key>value</key><value>nAves</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nAves</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>20</value></param>
<param><key>option</key><value>nave</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nAve</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nsigma</value></param>
<param><key>value</key><value>nsigmas</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nsigmas</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>5.5</value></param>
<param><key>option</key><value>nsigma</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>nsigma</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>numin</value></param>
<param><key>value</key><value>(Frequency - (Bandwidth/2.))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>observer</value></param>
<param><key>value</key><value>observers_save</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>observers_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>Science Aficionado</value></param>
<param><key>option</key><value>observers</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>observer</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>telescope_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>Bubble Wrap Horn</value></param>
<param><key>option</key><value>telescope</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>Telescope</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>2*fftsize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.hamming(fftsize)</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>The sequence of vector medians removes temporary RFI</value></param>
</block>
<block>
<key>radio_astro_detect</key>
<param><key>id</key><value>radio_astro_detect_0</value></param>
<param><key>mode</key><value>EventMode</value></param>
<param><key>dms</key><value>nsigma</value></param>
<param><key>bw</key><value>Bandwidth</value></param>
<param><key>f_obs</key><value>Frequency</value></param>
<param><key>t_int</key><value>fftsize*1.e-6/Bandwidth</value></param>
<param><key>vec_length</key><value>2*fftsize</value></param>
</block>
<block>
<key>radio_astro_ra_ascii_sink</key>
<param><key>id</key><value>radio_astro_ra_ascii_sink_0</value></param>
<param><key>azimuth</key><value>Azimuth</value></param>
<param><key>bandwidth</key><value>Bandwidth</value></param>
<param><key>device</key><value>device_save</value></param>
<param><key>elevation</key><value>Elevation</value></param>
<param><key>frequency</key><value>Frequency</value></param>
<param><key>gain1</key><value>float(Gain1)</value></param>
<param><key>gain2</key><value>float(IF_attn)</value></param>
<param><key>gain3</key><value>float(IF_attn)</value></param>
<param><key>observers</key><value>observer</value></param>
<param><key>obstype</key><value>0</value></param>
<param><key>record</key><value>Record</value></param>
<param><key>setup</key><value>ObsName+".not"</value></param>
<param><key>site</key><value>telescope_save</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>nave</key><value>nAve</value></param>
<param><key>nmedian</key><value>4**5</value></param>
</block>
<block>
<key>radio_astro_ra_event_log</key>
<param><key>id</key><value>radio_astro_ra_event_log_0</value></param>
<param><key>logname</key><value></value></param>
<param><key>note</key><value>Event Detection</value></param>
<param><key>sample_rate</key><value>Bandwidth*1.e-6</value></param>
<param><key>vlen</key><value>2*fftsize</value></param>
</block>
<block>
<key>radio_astro_ra_event_sink</key>
<param><key>id</key><value>radio_astro_ra_event_sink_0</value></param>
<param><key>azimuth</key><value>Azimuth</value></param>
<param><key>sample_rate</key><value>Bandwidth*1.E-6</value></param>
<param><key>device</key><value>Device</value></param>
<param><key>elevation</key><value>Elevation</value></param>
<param><key>frequency</key><value>Frequency*1.E-6</value></param>
<param><key>gain1</key><value>float(Gain1)</value></param>
<param><key>note</key><value>Event Detection</value></param>
<param><key>observer</key><value>Observer</value></param>
<param><key>record</key><value>EventMode</value></param>
<param><key>setup</key><value>ObsName+"Event.not"</value></param>
<param><key>telescope</key><value>Telescope</value></param>
<param><key>vlen</key><value>2*fftsize</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_0_1</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_0_1_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>sdrplay_rsp1a_source</key>
<param><key>id</key><value>sdrplay_rsp1a_source_0</value></param>
<param><key>agc_enabled</key><value>False</value></param>
<param><key>bw</key><value>8000</value></param>
<param><key>biasT</key><value>bool(BiasOn)</value></param>
<param><key>bcast_notch</key><value>BroadcastNotch</value></param>
<param><key>dab_notch</key><value>DabNotch</value></param>
<param><key>dc_offset_mode</key><value>DcOffsetMode</value></param>
<param><key>debug_enabled</key><value>bool(DebugOn)</value></param>
<param><key>device_serial</key><value>'0'</value></param>
<param><key>if_atten_db</key><value>int(IF_attn)</value></param>
<param><key>ifType</key><value>0</value></param>
<param><key>iq_balance_mode</key><value>IQMode</value></param>
<param><key>lna_atten_step</key><value>int(Gain1)</value></param>
<param><key>lo_mode</key><value>1</value></param>
<param><key>rf_freq</key><value>int(Frequency)</value></param>
<param><key>sample_rate</key><value>int(Bandwidth)</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>time_remaining</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>radio_astro_vmedian_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>radio_astro_detect_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_detect_0</source_block_id><sink_block_id>radio_astro_ra_event_log_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_detect_0</source_block_id><sink_block_id>radio_astro_ra_event_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_ra_ascii_sink_0</source_block_id><sink_block_id>time_remaining</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0</source_block_id><sink_block_id>radio_astro_ra_ascii_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_0</source_block_id><sink_block_id>radio_astro_vmedian_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_0_0</source_block_id><sink_block_id>radio_astro_vmedian_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_0_1</source_block_id><sink_block_id>radio_astro_vmedian_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_0_1_0</source_block_id><sink_block_id>radio_astro_vmedian_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp1a_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp1a_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
