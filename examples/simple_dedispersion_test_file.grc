<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dedisperse</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>dedispersion test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Dedisperse</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>705e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ndm</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nt</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec_length</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>pulse_32ms_512freq_50dm_705mhz_10mhzbw_float32.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>nt</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>1000</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>nt</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>name</key><value>"Input"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>vec_length</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>7</value></param>
<param><key>ymin</key><value>4</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>name</key><value>"output_direct"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>ndm</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>7</value></param>
<param><key>ymin</key><value>4</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>name</key><value>"output"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>vec_length</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>7</value></param>
<param><key>ymin</key><value>4</value></param>
</block>
<block>
<key>radio_astro_dedispersion</key>
<param><key>id</key><value>radio_astro_dedispersion_0</value></param>
<param><key>bw</key><value>samp_rate/1e6</value></param>
<param><key>dms</key><value>50</value></param>
<param><key>f_obs</key><value>freq/1e6</value></param>
<param><key>nt</key><value>nt</value></param>
<param><key>t_int</key><value>1</value></param>
<param><key>vec_length</key><value>vec_length</value></param>
</block>
<block>
<key>radio_astro_hdf5_sink</key>
<param><key>id</key><value>radio_astro_hdf5_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fname</key><value>testing.h5</value></param>
<param><key>freq_start</key><value>freq-samp_rate/2</value></param>
<param><key>freq_step</key><value>samp_rate/vec_length</value></param>
<param><key>n_inputs</key><value>1</value></param>
<param><key>notes</key><value></value></param>
<param><key>pointing</key><value></value></param>
<param><key>save_toggle</key><value></value></param>
<param><key>vec_length</key><value>ndm</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>radio_astro_dedispersion_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_dedispersion_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
