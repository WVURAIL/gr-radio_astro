<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>collect</value></param>
<param><key>value</key><value>"nocal_nofilter"</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label0</key><value>"Filtered spectrum with no calibration"</value></param>
<param><key>label1</key><value>"Spectrum with calibration"</value></param>
<param><key>label2</key><value>"Hot calibration"</value></param>
<param><key>label3</key><value>"Cold calibration"</value></param>
<param><key>label4</key><value>"Unfiltered spectrum with no calibration"</value></param>
<param><key>label</key><value>"Collect Data"</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>"nocal"</value></param>
<param><key>option1</key><value>"cal"</value></param>
<param><key>option2</key><value>"hot"</value></param>
<param><key>option3</key><value>"cold"</value></param>
<param><key>option4</key><value>"nocal_nofilter"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>custom_window</value></param>
<param><key>value</key><value>sinc*np.hamming(4*vec_length)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1419e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_start</value></param>
<param><key>value</key><value>freq - samp_rate/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_step</value></param>
<param><key>value</key><value>samp_rate/vec_length</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>integration_time</value></param>
<param><key>comment</key><value>Integration time in secs</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>comment</key><value>File path length for captured spectra</value></param>
<param><key>value</key><value>"/home/dspradio/grc-data/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile</value></param>
<param><key>comment</key><value>Filename for hdf5 sink block</value></param>
<param><key>value</key><value>prefix + timenow + ".h5"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>save_toggle_csv</value></param>
<param><key>value</key><value>"False"</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label0</key><value>Write to File</value></param>
<param><key>label1</key><value>Not writing to file</value></param>
<param><key>label</key><value>Write to CSV files</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>"True"</value></param>
<param><key>option1</key><value>"False"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>save_toggle_hdf5</value></param>
<param><key>value</key><value>"False"</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>label0</key><value>Write to File</value></param>
<param><key>label1</key><value>Not writing to file</value></param>
<param><key>label</key><value>Write HDF5</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>"True"</value></param>
<param><key>option1</key><value>"False"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sinc</value></param>
<param><key>value</key><value>np.sinc(sinc_sample_locations/np.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sinc_sample_locations</value></param>
<param><key>value</key><value>np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/vec_length)</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>spectrumcapture_toggle</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Capture Latest Spectrum</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timenow</value></param>
<param><key>value</key><value>datetime.now().strftime("%Y-%m-%d_%H.%M.%S")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec_length</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ymax</value></param>
<param><key>value</key><value>200000</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>ymax</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>50</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>1000000000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ymin</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>ymin</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1000</value></param>
<param><key>step</key><value>50</value></param>
<param><key>stop</key><value>5000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>vec_length</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>2*vec_length</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0_0</value></param>
<param><key>delay</key><value>3*vec_length</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0_0</value></param>
<param><key>decim</key><value>int(integration_time*samp_rate/vec_length)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>custom_window[0:vec_length]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>custom_window[vec_length:2*vec_length]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>custom_window[2*vec_length:3*vec_length]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2</value></param>
<param><key>const</key><value>custom_window[-vec_length:]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>comment</key><value>strean</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec_length</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec_length</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>vec_length</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(vec_length)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>Controls for scaling the graph</value></param>
<param><key>note</key><value>GRAPH OPTIONS</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>comment</key><value>Check/change these variables before each run.</value></param>
<param><key>note</key><value>USER DEFINED VARIABLES:</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>comment</key><value>Polyphase filter bank functions</value></param>
<param><key>note</key><value>CUSTOM FUNCTIONS</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>10</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>12</value></param>
<param><key>gain0</key><value>17</value></param>
<param><key>args</key><value>airspy=0,bias=1,pack=0</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>gui_hint</key><value>9,3,1,1</value></param>
<param><key>xmax</key><value>1</value></param>
<param><key>xmin</key><value>-1</value></param>
<param><key>bins</key><value>100</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>gui_hint</key><value>9,0,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>vec_length</value></param>
<param><key>x_axis_label</key><value>"frequency"</value></param>
<param><key>x_start</key><value>freq - samp_rate/2</value></param>
<param><key>x_step</key><value>samp_rate/vec_length</value></param>
<param><key>ymax</key><value>400</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>y_axis_label</key><value>"System Temperature"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>9,2,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>vec_length</value></param>
<param><key>x_axis_label</key><value>"frequency"</value></param>
<param><key>x_start</key><value>freq - samp_rate/2</value></param>
<param><key>x_step</key><value>samp_rate/vec_length</value></param>
<param><key>ymax</key><value>200</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>y_axis_label</key><value>"Gain"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0_1</value></param>
<param><key>gui_hint</key><value>4,0,5,6</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>vec_length</value></param>
<param><key>x_axis_label</key><value>"Frequency"</value></param>
<param><key>x_start</key><value>freq - samp_rate/2</value></param>
<param><key>x_step</key><value>samp_rate/vec_length</value></param>
<param><key>ymax</key><value>ymax</value></param>
<param><key>ymin</key><value>ymin</value></param>
<param><key>y_axis_label</key><value>"Signal"</value></param>
</block>
<block>
<key>radio_astro_csv_filesink</key>
<param><key>id</key><value>radio_astro_csv_filesink_0</value></param>
<param><key>comment</key><value>Choose "Write to File" to write data to a .csv file
at the path specified in Prefix.</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>prefix</key><value>prefix</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>save_toggle</key><value>save_toggle_csv</value></param>
<param><key>vec_length</key><value>vec_length</value></param>
</block>
<block>
<key>radio_astro_hdf5_sink</key>
<param><key>id</key><value>radio_astro_hdf5_sink_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fname</key><value>recfile</value></param>
<param><key>freq_start</key><value>freq - samp_rate/2</value></param>
<param><key>freq_step</key><value>samp_rate/vec_length</value></param>
<param><key>n_inputs</key><value>1</value></param>
<param><key>notes</key><value>Green Bank; integration = 1 s</value></param>
<param><key>pointing</key><value>A0E75.5</value></param>
<param><key>save_toggle</key><value>save_toggle_hdf5</value></param>
<param><key>vec_length</key><value>vec_length</value></param>
</block>
<block>
<key>radio_astro_systemp_calibration</key>
<param><key>id</key><value>radio_astro_systemp_calibration_0</value></param>
<param><key>collect</key><value>collect</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>prefix</key><value>prefix</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>spectrumcapture_toggle</key><value>spectrumcapture_toggle</value></param>
<param><key>vec_length</key><value>vec_length</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>blocks_integrate_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0_0</source_block_id><sink_block_id>radio_astro_systemp_calibration_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_systemp_calibration_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_systemp_calibration_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_systemp_calibration_0</source_block_id><sink_block_id>radio_astro_csv_filesink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_systemp_calibration_0</source_block_id><sink_block_id>radio_astro_hdf5_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_systemp_calibration_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
