<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>NsfIntegrate80</value></param>
<param><key>author</key><value>Glen Langston</value></param>
<param><key>description</key><value>Astronomy with 8.0 MHz SDRPlay RSP 1A</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>NsfIntegrate: SDRPlay 8MHz Astronomical Obs.</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Azimuth</value></param>
<param><key>value</key><value>Azimuth_save</value></param>
<param><key>gui_hint</key><value>0,7,1,2</value></param>
<param><key>label</key><value>Azimuth</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Azimuth_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>90.</value></param>
<param><key>option</key><value>azimuth</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Azimuth</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Bandwidth</value></param>
<param><key>value</key><value>Bandwidths</value></param>
<param><key>gui_hint</key><value>1,5,1,2</value></param>
<param><key>label</key><value>Bandwidth</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Bandwidths</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>8.e6</value></param>
<param><key>option</key><value>bandwidth</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Bandwidth</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>BiasOn</value></param>
<param><key>value</key><value>BiasOn_save</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>BiasOn</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>BiasOn_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>biason</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>BiasOn</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>BroadcastNotch</value></param>
<param><key>value</key><value>BroadcastNotch_save</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>9,2,1,2</value></param>
<param><key>label</key><value>BroadcastNotch</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>BroadcastNotch_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>broadcastnotch</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>BroadcastNotch</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ConfigFile</value></param>
<param><key>value</key><value>ObsName+".conf"</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>DabNotch</value></param>
<param><key>value</key><value>DabNotch_save</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>DabNotch</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>DabNotch_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>dabnotch</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>DabNotch</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>DcOffsetMode</value></param>
<param><key>value</key><value>DcOffsetMode_save</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>9,0,1,2</value></param>
<param><key>label</key><value>DcOffsetMode</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>DcOffsetMode_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>dcoffsetmode</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>DcOffsetMode</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>DebugOn</value></param>
<param><key>value</key><value>bool(DebugOn_save)</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>DebugOn</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>DebugOn_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>debugon</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>DebugOn</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Device</value></param>
<param><key>value</key><value>device_save</value></param>
<param><key>gui_hint</key><value>2,0,1,2</value></param>
<param><key>label</key><value>Dev</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Elevation</value></param>
<param><key>value</key><value>Elevation_save</value></param>
<param><key>gui_hint</key><value>1,7,1,2</value></param>
<param><key>label</key><value>Elevation</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Elevation_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>90.</value></param>
<param><key>option</key><value>elevation</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Elevation</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Frequency</value></param>
<param><key>value</key><value>Frequencys</value></param>
<param><key>gui_hint</key><value>0,5,1,2</value></param>
<param><key>label</key><value>Freq. Hz</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Frequencys</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>1420.4e6</value></param>
<param><key>option</key><value>Frequency</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Frequency</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Gain1</value></param>
<param><key>value</key><value>Gain1s</value></param>
<param><key>gui_hint</key><value>3,0,1,2</value></param>
<param><key>label</key><value>Gain1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Gain1s</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>49.</value></param>
<param><key>option</key><value>gain1</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Gain1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain2</value></param>
<param><key>value</key><value>IF_attn</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain3</value></param>
<param><key>value</key><value>IF_attn</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>H1</value></param>
<param><key>value</key><value>1420.406E6</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>IF_attn</value></param>
<param><key>value</key><value>IF_attn_save</value></param>
<param><key>gui_hint</key><value>8,3,1,2</value></param>
<param><key>label</key><value>IF_attn</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>IF_attn_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>30</value></param>
<param><key>option</key><value>ifattn</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>IF_attn</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>IQMode</value></param>
<param><key>value</key><value>IQMode_save</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>9,4,1,2</value></param>
<param><key>label</key><value>IQMode</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>IQMode_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>iqmode</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>IQMode</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ObsName</value></param>
<param><key>value</key><value>"Integrate80"</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Record</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>6,0,1,1</value></param>
<param><key>label0</key><value>! ! Wait ! !</value></param>
<param><key>label1</key><value>AVERAGE</value></param>
<param><key>label2</key><value>Save</value></param>
<param><key>label</key><value>Rec</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Telescope</value></param>
<param><key>value</key><value>telescope_save</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label</key><value>Tel</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Xaxis</value></param>
<param><key>value</key><value>xaxis_save</value></param>
<param><key>gui_hint</key><value>8,5,1,3</value></param>
<param><key>label0</key><value>Frequency (MHz)</value></param>
<param><key>label1</key><value>Velocity (km/sec)</value></param>
<param><key>label2</key><value>Channels</value></param>
<param><key>label</key><value>Xaxis</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>device_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>airspy,bias=1,pack=1</value></param>
<param><key>option</key><value>device</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>Device</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>fftsize_save</value></param>
<param><key>gui_hint</key><value>1,2,1,2</value></param>
<param><key>label</key><value>FFT_size</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>fftsize_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>option</key><value>fftsize</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>fftsize</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>nAve</value></param>
<param><key>value</key><value>nAves</value></param>
<param><key>gui_hint</key><value>0,2,1,2</value></param>
<param><key>label</key><value>N_Ave.</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nAves</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>20</value></param>
<param><key>option</key><value>nave</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nAve</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>numin</value></param>
<param><key>value</key><value>(Frequency - (Bandwidth/2.))</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>observer</value></param>
<param><key>value</key><value>observers_save</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>label</key><value>Who</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>observers_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>Science Aficionado</value></param>
<param><key>option</key><value>observers</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>observer</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>obstype</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>7,0,1,1</value></param>
<param><key>label0</key><value>Survey</value></param>
<param><key>label1</key><value>Hot/Cold</value></param>
<param><key>label2</key><value>Ref</value></param>
<param><key>label</key><value>Obs</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>telescope_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>Bubble Wrap Horn</value></param>
<param><key>option</key><value>telescope</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>Telescope</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>units</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>8,0,1,1</value></param>
<param><key>label0</key><value>Counts</value></param>
<param><key>label1</key><value>dB</value></param>
<param><key>label2</key><value>Kelvins</value></param>
<param><key>label3</key><value>K - Fit</value></param>
<param><key>label</key><value>Units</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>xaxis_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>Xaxis</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>Xaxis</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>xaxis_save_0</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>Xaxis</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>Xaxis</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xmins</value></param>
<param><key>value</key><value>[numin*1E-6, (H1 - numin)*(3E5/H1), 0 ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xsteps</value></param>
<param><key>value</key><value>[Bandwidth*1.E-6/fftsize, -Bandwidth*3.E5/(H1*fftsize), 1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ymaxs</value></param>
<param><key>value</key><value>[5., 10., 180., 80.]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ymins</value></param>
<param><key>value</key><value>[ 0.01,  -20,  90.,-5.] </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>yunits</value></param>
<param><key>value</key><value>["Counts", "Power (dB)", "Intensity (Kelvins)", "Intensity (K)"]</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.hamming(fftsize)</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>The sequence of vector medians removes temporary RFI</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>gui_hint</key><value>4,0,2,2</value></param>
<param><key>label1</key><value>I</value></param>
<param><key>label2</key><value>Q</value></param>
<param><key>xmax</key><value>.5</value></param>
<param><key>xmin</key><value>-.5</value></param>
<param><key>bins</key><value>100</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>fftsize</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1.</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>8,8,1,2</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>T Remains:</value></param>
<param><key>unit1</key><value>(s)</value></param>
<param><key>max</key><value>nAve * fftsize * 1024. / Bandwidth</value></param>
<param><key>min</key><value>0.</value></param>
<param><key>update_time</key><value>1.</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>gui_hint</key><value>2,2,6,8</value></param>
<param><key>alpha1</key><value>2.</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>label1</key><value>Latest</value></param>
<param><key>color2</key><value>"dark green"</value></param>
<param><key>label2</key><value>Median</value></param>
<param><key>width2</key><value>3</value></param>
<param><key>color3</key><value>"red"</value></param>
<param><key>label3</key><value>Hot</value></param>
<param><key>width3</key><value>2</value></param>
<param><key>color4</key><value>"blue"</value></param>
<param><key>label4</key><value>Cold</value></param>
<param><key>width4</key><value>2</value></param>
<param><key>label5</key><value>Ref</value></param>
<param><key>width5</key><value>3</value></param>
<param><key>nconnections</key><value>5</value></param>
<param><key>ref_level</key><value>0.5*(ymins[units] + ymaxs[units])</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>.5</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_axis_label</key><value>""</value></param>
<param><key>x_start</key><value>xmins[Xaxis]</value></param>
<param><key>x_step</key><value>xsteps[Xaxis]</value></param>
<param><key>ymax</key><value>ymaxs[units]</value></param>
<param><key>ymin</key><value>ymins[units]</value></param>
<param><key>y_axis_label</key><value>Intensity</value></param>
</block>
<block>
<key>radio_astro_ra_ascii_sink</key>
<param><key>id</key><value>radio_astro_ra_ascii_sink_0</value></param>
<param><key>azimuth</key><value>Azimuth</value></param>
<param><key>bandwidth</key><value>Bandwidths</value></param>
<param><key>device</key><value>device_save</value></param>
<param><key>elevation</key><value>Elevation</value></param>
<param><key>frequency</key><value>Frequencys</value></param>
<param><key>gain1</key><value>Gain1</value></param>
<param><key>gain2</key><value>float(Gain2)</value></param>
<param><key>gain3</key><value>float(Gain2)</value></param>
<param><key>observers</key><value>observer</value></param>
<param><key>obstype</key><value>obstype</value></param>
<param><key>record</key><value>Record</value></param>
<param><key>setup</key><value>ObsName+".not"</value></param>
<param><key>site</key><value>telescope_save</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>nave</key><value>nAve</value></param>
<param><key>nmedian</key><value>4**5</value></param>
</block>
<block>
<key>radio_astro_ra_integrate</key>
<param><key>id</key><value>radio_astro_ra_integrate_1</value></param>
<param><key>azimuth</key><value>Azimuth</value></param>
<param><key>bandwidth</key><value>Bandwidths</value></param>
<param><key>count</key><value>int(4**5)</value></param>
<param><key>elevation</key><value>Elevation</value></param>
<param><key>frequency</key><value>Frequencys</value></param>
<param><key>inttype</key><value>Record</value></param>
<param><key>observers</key><value>observers_save</value></param>
<param><key>obstype</key><value>obstype</value></param>
<param><key>setup</key><value>ObsName+".not"</value></param>
<param><key>tcold</key><value>10.</value></param>
<param><key>thot</key><value>295.</value></param>
<param><key>units</key><value>units</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_1</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_2</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_vmedian</key>
<param><key>id</key><value>radio_astro_vmedian_0_2_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>sdrplay_rsp1a_source</key>
<param><key>id</key><value>sdrplay_rsp1a_source_0</value></param>
<param><key>agc_enabled</key><value>False</value></param>
<param><key>bw</key><value>8000</value></param>
<param><key>biasT</key><value>BiasOn</value></param>
<param><key>bcast_notch</key><value>BroadcastNotch</value></param>
<param><key>dab_notch</key><value>DabNotch</value></param>
<param><key>dc_offset_mode</key><value>DcOffsetMode</value></param>
<param><key>debug_enabled</key><value>bool(DebugOn)</value></param>
<param><key>device_serial</key><value>'0'</value></param>
<param><key>if_atten_db</key><value>int(IF_attn)</value></param>
<param><key>ifType</key><value>0</value></param>
<param><key>iq_balance_mode</key><value>IQMode</value></param>
<param><key>lna_atten_step</key><value>int(Gain1)</value></param>
<param><key>lo_mode</key><value>1</value></param>
<param><key>rf_freq</key><value>int(Frequency)</value></param>
<param><key>sample_rate</key><value>int(Bandwidth)</value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>radio_astro_vmedian_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_ra_ascii_sink_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_ra_integrate_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>radio_astro_ra_integrate_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>radio_astro_ra_integrate_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>radio_astro_ra_integrate_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_ra_integrate_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0</source_block_id><sink_block_id>radio_astro_vmedian_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_0</source_block_id><sink_block_id>radio_astro_vmedian_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_1</source_block_id><sink_block_id>radio_astro_ra_ascii_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_1</source_block_id><sink_block_id>radio_astro_ra_integrate_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_2</source_block_id><sink_block_id>radio_astro_vmedian_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_vmedian_0_2_0</source_block_id><sink_block_id>radio_astro_vmedian_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp1a_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp1a_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
