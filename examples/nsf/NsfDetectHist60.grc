options:
  parameters:
    author: Glen Langston
    description: Event Detection using RTLSDR
    generate_options: qt_gui
    id: NsfDetectHist60
    output_language: python
    title: 'Nsf RTLSDR Event Detect: 3MHz'
  states: {}

blocks:
- name: Azimuth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,7,1,2
    label: Azimuth
    type: real
    value: Azimuth_save
  states: {}
- name: Azimuth_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: azimuth
    section: main
    type: real
    value: '180.'
    writeback: Azimuth
  states: {}
- name: Bandwidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,5,1,2
    label: Bandwidth
    type: real
    value: Bandwidths
  states: {}
- name: Bandwidths
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: bandwidth
    section: main
    type: real
    value: 6.e6
    writeback: Bandwidth
  states: {}
- name: ConfigFile
  id: variable
  parameters:
    value: ObsName+".conf"
  states: {}
- name: Device
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,2
    label: Dev
    type: string
    value: device_save
  states: {}
- name: Elevation
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,7,1,2
    label: Elevation
    type: real
    value: Elevation_save
  states: {}
- name: Elevation_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: elevation
    section: main
    type: real
    value: '90.'
    writeback: Elevation
  states: {}
- name: EventMode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,0, 1, 2
    label: Write Mode
    label0: Wait
    label1: Write
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: Frequency
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,5,1,2
    label: Freq. Hz
    type: real
    value: Frequencys
  states: {}
- name: Frequencys
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: frequency
    section: main
    type: real
    value: 1420.4e6
    writeback: Frequency
  states: {}
- name: Gain1
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,2
    label: Gain1
    type: real
    value: Gain1s
  states: {}
- name: Gain1s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain1
    section: main
    type: real
    value: '49.'
    writeback: Gain1
  states: {}
- name: Gain2
  id: variable
  parameters:
    value: '12.'
  states: {}
- name: Mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6,0,1,2
    label: Data Mode
    label0: Monitor
    label1: Detect
    num_opts: '2'
    option0: '0'
    option1: '2'
    type: int
    value: '2'
  states: {}
- name: ObsName
  id: variable
  parameters:
    value: '"Detect60"'
  states: {}
- name: Observer
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,2
    label: Who
    type: string
    value: observer_save
  states: {}
- name: Telescope
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,2
    label: Tel
    type: string
    value: telescope_save
  states: {}
- name: device_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: device
    section: main
    type: string
    value: airspy,bias=1,pack=1
    writeback: Device
  states: {}
- name: fftsize
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,2,1,2
    label: Sample_Size
    type: int
    value: fftsize_save
  states: {}
- name: fftsize_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: samplesize
    section: main
    type: int
    value: '2048'
    writeback: fftsize
  states: {}
- name: nsigma
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,2
    label: N Sigma
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.'
    step: '.1'
    stop: '10.'
    value: '5.0'
    widget: counter
  states: {}
- name: observer_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: observer
    section: main
    type: string
    value: Science Aficionado
    writeback: Observer
  states: {}
- name: telescope_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: telescope
    section: main
    type: string
    value: My Horn
    writeback: Telescope
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: 3,0,2,2
    label1: I
    label2: Q
    nconnections: '2'
    size: fftsize
    type: float
    update_time: '1'
    xmax: '.5'
    xmin: '-.5'
  states: {}
- name: radio_astro_detect_0
  id: radio_astro_detect
  parameters:
    bw: Bandwidth
    dms: nsigma
    f_obs: Frequency
    mode: Mode
    t_int: fftsize*1.e-6/Bandwidth
    vec_length: fftsize
  states: {}
- name: radio_astro_ra_event_sink_0
  id: radio_astro_ra_event_sink
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidth*1.E-6
    device: Device
    elevation: Elevation
    frequency: Frequency*1.E-6
    gain1: Gain1
    note: Event Detection
    observer: Observer
    record: EventMode
    setup: ObsName+".not"
    telescope: Telescope
    vlen: fftsize
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    affinity: '3'
    args: Device
    bb_gain0: float(Gain2)
    bw0: Bandwidth
    dc_offset_mode0: '2'
    freq0: Frequency
    gain0: Gain1
    gain_mode0: 'False'
    if_gain0: float(Gain2)
    sample_rate: Bandwidth
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_histogram_sink_x_0, '1']
- [blocks_stream_to_vector_0, '0', radio_astro_detect_0, '0']
- [radio_astro_detect_0, '0', radio_astro_ra_event_sink_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_float_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
