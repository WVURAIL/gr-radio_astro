options:
  parameters:
    author: Glen Langston
    description: Astronomy with 6MHz Airspy Mini Events and Spectra
    generate_options: no_gui
    id: NsfWatchNoGui60
    output_language: python
    run_options: run
    title: 'Nsf Detect+Spectra: Airspy-mini 6MHz Astronomical Obs.'
  states: {}

blocks:
- name: Azimuth
  id: variable
  parameters:
    value: float(Azimuth_save)
  states: {}
- name: Azimuth_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: azimuth
    section: main
    type: real
    value: '90.'
    writeback: Azimuth
  states: {}
- name: Bandwidth
  id: variable
  parameters:
    value: float(Bandwidths)
  states: {}
- name: Bandwidths
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: bandwidth
    section: main
    type: real
    value: 6.e6
    writeback: Bandwidth
  states: {}
- name: BiasOn
  id: variable
  parameters:
    value: bool(BiasOn_save)
  states: {}
- name: BiasOn_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: biason
    section: main
    type: bool
    value: 'False'
    writeback: BiasOn
  states: {}
- name: ConfigFile
  id: variable
  parameters:
    value: ObsName+".conf"
  states: {}
- name: DcOffsetMode
  id: variable
  parameters:
    value: bool(DcOffsetMode_save)
  states: {}
- name: DcOffsetMode_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: dcoffsetmode
    section: main
    type: bool
    value: 'False'
    writeback: DcOffsetMode
  states: {}
- name: DebugOn
  id: variable
  parameters:
    value: bool(DebugOn_save)
  states: {}
- name: DebugOn_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: debugon
    section: main
    type: bool
    value: 'False'
    writeback: DebugOn
  states: {}
- name: Device
  id: variable
  parameters:
    value: device_save
  states: {}
- name: Elevation
  id: variable
  parameters:
    value: float(Elevation_save)
  states: {}
- name: Elevation_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: elevation
    section: main
    type: real
    value: '90.'
    writeback: Elevation
  states: {}
- name: Frequency
  id: variable
  parameters:
    value: float(Frequencys)
  states: {}
- name: Frequencys
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: Frequency
    section: main
    type: real
    value: 1421.5e6
    writeback: Frequency
  states: {}
- name: Gain1
  id: variable
  parameters:
    value: Gain1s
  states: {}
- name: Gain1s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain1
    section: main
    type: real
    value: '21.'
    writeback: Gain1
  states: {}
- name: Gain2
  id: variable
  parameters:
    value: float(Gain2s)
  states: {}
- name: Gain2s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain2
    section: main
    type: real
    value: '0.'
    writeback: Gain2
  states: {}
- name: Gain3
  id: variable
  parameters:
    value: float(Gain3s)
  states: {}
- name: Gain3s
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: gain3
    section: main
    type: real
    value: '0.'
    writeback: Gain3
  states: {}
- name: H1
  id: variable
  parameters:
    value: 1420.406E6
  states: {}
- name: IQMode
  id: variable
  parameters:
    value: bool(IQMode_save)
  states: {}
- name: IQMode_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: iqmode
    section: main
    type: bool
    value: 'False'
    writeback: IQMode
  states: {}
- name: ObsName
  id: variable
  parameters:
    value: '"Integrate60"'
  states: {}
- name: Observer
  id: variable
  parameters:
    value: observers_save
  states: {}
- name: Samples
  id: variable
  parameters:
    value: int(fftsize_save)
  states: {}
- name: Telescope
  id: variable
  parameters:
    value: telescope_save
  states: {}
- name: device_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: device
    section: main
    type: string
    value: airspy,bias=1,pack=1
    writeback: Device
  states: {}
- name: fftsize
  id: variable
  parameters:
    value: fftsize_save
  states: {}
- name: fftsize_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: fftsize
    section: main
    type: int
    value: '1024'
    writeback: fftsize
  states: {}
- name: nAve
  id: variable
  parameters:
    value: int(nAves)
  states: {}
- name: nAves
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: nave
    section: main
    type: int
    value: '20'
    writeback: nAve
  states: {}
- name: nsigma
  id: variable
  parameters:
    value: float(nsigmas)
  states: {}
- name: nsigmas
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: nsigma
    section: main
    type: real
    value: '5.5'
    writeback: nsigma
  states: {}
- name: observer
  id: variable
  parameters:
    value: observers_save
  states: {}
- name: observers_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: observers
    section: main
    type: string
    value: Science Aficionado
    writeback: observer
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Bandwidth
  states: {}
- name: telescope_save
  id: variable_config
  parameters:
    config_file: ConfigFile
    option: telescope
    section: main
    type: string
    value: Bubble Wrap Horn
    writeback: Telescope
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.hamming(fftsize)
  states: {}
- name: note_1
  id: note
  parameters:
    note: The sequence of vector medians removes temporary RFI
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: Device
    bb_gain0: float(Gain3)
    bw0: Bandwidth
    dc_offset_mode0: DcOffsetMode
    freq0: Frequency
    gain0: float(Gain1)
    gain_mode0: 'False'
    if_gain0: float(Gain2)
    iq_balance_mode0: IQMode
    sample_rate: Bandwidth
    sync: sync
    type: fc32
  states: {}
- name: radio_astro_detect_0
  id: radio_astro_detect
  parameters:
    bw: Bandwidth
    dms: nsigma
    f_obs: Frequency
    mode: 'True'
    t_int: fftsize/Bandwidth
    vec_length: fftsize
  states: {}
- name: radio_astro_ra_ascii_sink_0
  id: radio_astro_ra_ascii_sink
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidth
    device: device_save
    elevation: Elevation
    frequency: Frequency
    gain1: float(Gain1)
    gain2: float(Gain2)
    gain3: float(Gain3)
    nave: nAve
    nmedian: 4**5
    observers: observer
    obstype: '0'
    record: '1'
    setup: ObsName+".not"
    site: telescope_save
    vlen: fftsize
  states: {}
- name: radio_astro_ra_event_sink_0
  id: radio_astro_ra_event_sink
  parameters:
    azimuth: Azimuth
    bandwidth: Bandwidth
    device: Device
    elevation: Elevation
    frequency: Frequency
    gain1: float(Gain1)
    note: Event Detection
    observer: Observer
    record: 'True'
    setup: ObsName+"Event.not"
    telescope: Telescope
    vlen: fftsize
  states: {}
- name: radio_astro_vmedian_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0_1
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: radio_astro_vmedian_0_0_1_0
  id: radio_astro_vmedian
  parameters:
    n: '4'
    vec_length: fftsize
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: DataVector
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: DataVector
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', radio_astro_vmedian_0_0_1, '0']
- [blocks_stream_to_vector_0_0, '0', radio_astro_detect_0, '0']
- [blocks_stream_to_vector_0_0, '0', virtual_sink_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [radio_astro_detect_0, '0', radio_astro_ra_event_sink_0, '0']
- [radio_astro_ra_ascii_sink_0, '0', blocks_null_sink_0, '0']
- [radio_astro_vmedian_0, '0', radio_astro_ra_ascii_sink_0, '0']
- [radio_astro_vmedian_0_0, '0', radio_astro_vmedian_0, '0']
- [radio_astro_vmedian_0_0_0, '0', radio_astro_vmedian_0_0, '0']
- [radio_astro_vmedian_0_0_1, '0', radio_astro_vmedian_0_0_1_0, '0']
- [radio_astro_vmedian_0_0_1_0, '0', radio_astro_vmedian_0_0_0, '0']
- [virtual_source_0, '0', fft_vxx_0_0, '0']

metadata:
  file_format: 1
